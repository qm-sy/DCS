# Keil uVision project DCS.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: SP_DCS_DCSA_HW1.20_SW001_20250627 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\SYSTEM\Inc;..\BSP\Inc;..\Core\Inc;..\Emembed\Inc
  group Source Group 1
    ./: STARTUP.A51
  group Driver
    ../Driver/: STC8H.h
  group SYSTEM
    ../SYSTEM/Src/: delay.c
  group Core
    ../Core/Src/: gpio.c main.c tim.c uart.c
  group BSP
    ../BSP/Src/: communication.c tm1722.c key.c
  group Emembed
    ../Emembed/Src/: common.c modbus_rtu.c
